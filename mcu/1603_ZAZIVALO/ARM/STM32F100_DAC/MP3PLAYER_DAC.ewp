# IAR project MP3PLAYER_DAC.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F100x4 ST STM32F100x4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F100C4; STM32F10X_LD_VL
  ICCARM.CCIncludePath2: Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\; Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\iar; ; Libraries\CMSIS\CM3\CoreSupport; Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; Libraries\STM32F10x_StdPeriph_Driver\inc; Libraries\STM32_EVAL; Libraries\STM32_EVAL\Common; Libraries\STM32_EVAL\STM32100B_EVAL
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MP3PLAYER_DAC.hex
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_LD_VL
  ILINK.IlinkOutputFile: MP3PLAYER_DAC_06082014.out
  group (top)
    ./: diskio.c diskio.h integer.h main.c pff.c pff.h pffconf.h stm32f10x_it.c
  group CMSIS
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Doc
    Doc/: Readme.txt
  group EWARMv5
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_cl.s startup_stm32f10x_hd.s startup_stm32f10x_hd_vl.s startup_stm32f10x_ld.s startup_stm32f10x_ld_vl.s startup_stm32f10x_md.s startup_stm32f10x_md_vl.s startup_stm32f10x_xl.s
  group StdPeriph_Driver
    Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
