# IAR project M32WavPlayer.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x300
  General.SCCStackSize: 0x300
  General.SCRStackSize: 64
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  General.GenDeviceSelectMenu: m32a ATmega32A
  ICCAVR.IccLang: 0
  ICCAVR.CCOptStrategy: 1
  ICCAVR.CCOptLevel: 0
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm32a.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.GenDeviceSelectMenu: 0 -v0, Max 256 byte data, 8 Kbyte code
  ICCAVR.CCDefines: NDEBUG
  ICCAVR.CCOptLevel: 3
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\lnk0t.xcl
  group (top)
    ./: diskio.c diskio.h integer.h main.c pff.c pff.h pffconf.h
