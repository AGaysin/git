# IAR project STM8S103_RFID.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F2P STM8S103F2P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x200
  General.GenHeapSize: 0x1000
  ICCSTM8.CCIncludePath2: Libraries\STM8_TouchSensing_Driver\inc; Libraries\STM8S_StdPeriph_Driver\inc; Project\Discover\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: STM8S103F2P_RFID_V12.hex
  ILINK.IlinkOutputFile: STM8S103F2P_RFID.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    Debug/Exe/: FWLib.a
    Project/Discover/src/: main.c
