<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\FWLib.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\STM8S103_RFID.ewp</path>
  </project>
  <batchBuild/>
</workspace>


